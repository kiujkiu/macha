# Repository kiujkiu/macha

## KiCad design v1.2/pcb/key_board_v1_2/key_board_v1_2.kicad_pcb

File v1.2/README.md:

# V1.2 结构 (2026-11-10 起)

V1.0 基础上改: 新电机 Φ55×21.5、3D 打印底盘 Φ220×6 (合并电机控制板 + 散热片槽)、立柱回 V0.4 柱位、承载盘外唇 Φ178 (11-14 改回 V0.4 Φ170)。
兼容 V1.0 金属立柱 和 V1.1 玻璃罩 (OD200×5×450)。当前为 **方案 C**: 电机直接装在平底盘上, 托无线供电法兰盘的线圈环单独打印, 电机以上整体降 10.2。

| 路径 | 内容 |
|---|---|
| `assembly_v1_2_*.3mf` | 组合预览 (3MF, 分件带颜色); 玻璃罩版整机分 `_合并` / `_分体外卡环` 两份 |
| `models/base_disc_v1_2/` | 底盘 STL + STEP (打印件) |
| `models/coil_ring_v1_2/` | 线圈环 STL + STEP (打印件, 套环 Φ77/Φ59 高 9.3, 内管 Φ63 到法兰盘顶 13.3, 8×M3 r34) |
| `models/flange_disc_v1_2/` | 法兰盘: V0.4 flange_disc 底板减 3 (4.5→1.5), 中心孔补到 Φ63.4, 8×M3 改 r34 |
| `models/mounting_flange_v1_2/` | 安装法兰: V0.4 件外裙同步短 3, 板顶减 0.5 (3→2.5), 16 个 Φ7 沉孔深 1.5; 中心孔补到 Φ59.4, 内圈 8 孔改 r34 |
| `models/glass_shroud_v1_2/` | 玻璃罩下罩+定位环 合并版 (11-11 按用户草图): 实心墙 r92–110 (外面与底盘齐平) z0–32, 玻璃 OD200×5 H245 坐 z32 (=承载盘顶), 内卡 r90.8–94.8 (厚 4) 深 20, 外卡 r100.2–110 深 10 斜顶 (外缘留 1.5 直边); 下罩固定 (11-11 第二版): 四角三角块厚 5, M6 在 r85 @45°+90k (Φ14 让位圆贴内墙), M6×12 盘底沉孔往上, 螺母压三角块顶 (z5–10, 定子盘/安装法兰开 Φ14 让位); 11-12 改: 定子盘用中央 8×M3 (r34) 锁底盘, 定子盘回原 Φ165 / 安装法兰 Φ170 (保留 V0.4 原外裙 r82.5–85, 同步短到 z9.3 = 定子盘底; 16:28 版误切外裙并留 0.3 薄片, 已修); 6 个托块保留 (宽 12, r76→墙, Φ12 端头, 高 z9.3 托住定子盘外缘), 不开孔; 11-12 再改: 下罩 4 孔 M6 → M3 (M3x10 盘底 Φ6.5×3.5 沉孔往上, 三角块 Φ3.4, M3 螺母压三角块顶, 定子盘/安装法兰让位 Φ14 → Φ10); 定子盘/安装法兰外圈 r78 8 孔恢复作上下盖互锁: 上盖 Φ3.2 通孔 + 原 Φ7 沉孔, 下盖底面压 M3 铜螺母 Φ4.2×3 (顶留 1), 螺丝 M3x5; 线圈环套环改方座 ±35.5 (四角倒角 5, 11-12), 四角 4×M3x10 (±29.5) 盘底 Φ6.5×3.5 沉孔往上穿四角 Φ3.2 通孔, 顶面上 M3 螺母 (装定子盘前先固定线圈环); 11-12 再改: Φ77 圆 (托定子盘) 以内保持 z9.3 高, 圆外四角只留 5 厚, 电机出线口改到 -Y (255–285°), 控制板内移到 36.25; XT60 压块开口 0° (+X) |
| `models/glass_shroud_split_v1_2/` + `glass_clamp_ring_v1_2/` | 分体版: 下罩 + 外卡环 (三角区单独件, 环底 2×2 凸筋插下罩顶槽, 单边 0.1); 玻璃先套内卡再从上套环 |
| `models/glass_top_v1_2/` + `glass_top_hub_v1_2/` | **玻璃上** (顶盖环, 11-13) + 中心卡扣堵头; 外购圆环玻璃 OD180×ID20×10 只进装配 (供应商图在 `models/glass_top_disc_v1_2/`, 用户自画)。详见文末「玻璃上」节 |
| XT60 | 复用 `../models/xt60_clamp_16p6x9p2x23p9` 压块+底垫 (叠高 13), 0° (+X) 方向接头口朝外 (11-11 用户: 别和控制板重合; 网格孔 (87.5,±12.5) 被压块盖住不开), 口面 r112.5 (伸出底盘 2.5, 内端让安装法兰外裙); 底盘加 2×M6 (r100, 孔距 25), M6×20 从盘底上锁, 螺母压块顶 (下罩留 Φ14 井) |
| `scripts/build_v1_2.py` | 主参数化建模 (OCP) |
| `scripts/export_3mf_v1_2.py` | 出上面的 3MF 与 models/ 下 STL/STEP |
| `scripts/check_v1_2.py` | 点采样 + cKDTree 干涉检查 (别用 BRepExtrema, 会卡死) |
| `scripts/fasteners_v1_2.py` | 紧固件装配预览: 按实物 (M3 超薄头 Φ7×1.5 / 法兰螺母 Φ7.6×3.7 / 铜螺母 Φ4.2) 放件, 出 `assembly_v1_2_整机+螺丝.3mf` + 干涉/啮合表 (只 import build_v1_2, 不写 models/) |
| `BOM_紧固件_v1_2.md` (+ `.csv`) | 紧固件采购清单 (每处规格/数量/长度理由, 待确认项) |
| `scripts/frames_v4_stl2step.py`, `m2b.py` | V0.4 顶轴承架 STL→STEP (结果已在 src/) |
| `src/` | 依赖的 V1.0/V0.4/V1.1 源 STEP; 控制板 STEP 读 `../v1.0/boards/step/motor_ctrl_2026-10-23.step` |
| `out/` | 临时输出 (不入库) |

运行 (需 OCP + numpy + scipy; 仓库 `.venv` 有 OCP, 干涉检查另需 `uv pip install scipy`):

```bash
cd v1.2/scripts && ../../.venv/bin/python export_3mf_v1_2.py
```

## 2026-11-12 晚 改动 (以此为准, 上表个别旧数字已被覆盖)
- **Φ7 规则**: 安装法兰 A/B 沉孔 Φ7 = 定子盘内外墙宽 (`CB7`)。内墙 r31.7–38.7、外墙 r75.5–82.5 (线圈腔 r38.7–75.5, 底 1.5); 螺丝居中: 中央 8×M3 **r34 → r35.2** (`R_SCREW`, 底盘 G / 线圈环 A / 定子盘 A / 安装法兰 A 同步), 上下盖 8×M3 **r79** (`LID_R`; V0.4 原 r77.5 与误开的 r78 已补实)
- **线圈环总高 16**: 方座顶 9.3 → **9.5** (`FL_UP` 1.0 → 1.2, 定子盘 Z9.5–13.5 / 安装法兰 Z13.5–16 一起上移 0.2, 转子不动); 内管 Φ63 穿定子盘+安装法兰到 **Z16** (6.5); 安装法兰中心孔 Φ59.4 → **Φ63.4**
- **下罩**: 墙内面改 = 内卡内面 **r90.8 一条直线到底** (原 r92, Z32 处有 1.2 台阶); A 孔螺母按 Φ8 贴墙内面 ⇒ 孔心 r85 → **r86.8** (孔心到内圆 4; `SH_R`, 底盘 F 沉孔同步); 三角块厚 5; **6 个托块 B 取消**; 定子盘/安装法兰的 Φ10 让位缺口取消 (螺母 r82.8–90.8 在定子盘 r82.5 外, 顶 Z7.4 < 定子盘底 Z9.5)
- **下罩三角块加强筋** (用户 11-12 夜): 每个三角块两条直边 (x=±51 / y=±51) 各一片斜筋 ×8, 厚 2.5 (`GU_T`), 外侧面齐直边、筋在块上方; 尖角 r72 Z5 → 内侧面 r85.5 处 Z`FL_Z0`−0.5 (定子盘/外裙底下 0.5) → 贴墙 Z15 (`GU_ZH`, 承载盘/毂盘底 Z21.5 下), 墙内全长熔一体; 合并版/分体版同 (分体版由 seat 切出)。离法兰螺母 3.9 (Φ8 圆), 离外裙 0.62, 离卡件 0.85 / 电容 1.15 (与三角块原值同)。预览 `out/seat_gusset_preview.png`
- 安装法兰外裙 r82.5–85 恢复 (V0.4 原件, 16:28 版误切)
- 干涉 (check_v1_2): 电容离定子盘 0.09 (原压入 0.06); 3 根排针仍顶进定子盘外缘约 0.59 (唯一非零 0.499 mm³); 内管↔安装法兰中心孔单边 0.2; 下罩螺母↔外裙竖向 2.1; 下罩↔控制板 3.02 / ↔承载盘 1.78 / ↔转子盘 3.28
- 2D 图纸: `scripts/build_drawings_v1_2.py` (+ 引擎 `drawing_v1_2.py`, 版式同 v0.2 hub_disc: 俯视 Φ 链 + 剖视 A-A + 每种非通孔详图), 输出 `models/<件>/<件>_drawing.pdf`
- **底盘 M3 往上装沉孔 Φ6.5×3.5 → Φ7×2** (用户 11-12; `M3_CB_D`/`M3_CB_H`, D 电机 / E 线圈环四角 / F 下罩; 铜螺母孔 G/H 与 M6 沉孔不动)。螺丝头底面 Z-2.5 → **Z-4**: E/F 原 M3×10 尾端只到 Z6, 螺母 Z5..7.4 只吃进 1 (约 2 牙), 不够 ⇒ **改 M3×12** (尾端 Z8, 穿出螺母 0.6); 电机 D 进电机螺纹长 = L−4 (原 L−2.5, 少 1.5): M3×6 只剩 2, **建议 M3×8 (进 4)**, 视电机螺孔深度可用 M3×8~10。E 角孔 Φ7 沉孔离相邻 M6 沉孔壁厚 1.31 (原 1.56, assert ≥1.0 通过)
- **紧固件** (`fasteners_v1_2.py`, 清单 `BOM_紧固件_v1_2.md`): 电机 4×M3×8 (进 4, 待电机螺孔深度) / 线圈环角 4×M3×12 + 法兰螺母 (尾端 Z8, 离法兰盘 1.5) / 下罩 4×M3×14 + 法兰螺母 (吃满) / 中央 8×M3×20 (尾端缩进底面 0.5) / 上下盖 8×M3×5 (尾端齐法兰盘底) / 控制板 4×M3×6 / XT60 2×M6×20; 铜螺母 M3×4 ×12 (底盘) + M3×3 ×8 (法兰盘)。干涉: 只有线圈环四角法兰螺母 Φ7.6 吃进 Φ77 圆台 0.58 (1.547 mm³/颗) → 已按方案 a 处理, 见下条; Φ7 头落 Φ7 沉孔零径向间隙
- **线圈环圆台四角让位 (用户 11-12 方案 a)**: 以 4 个角孔 (±29.5, ±29.5) 为心切 **Φ8.2** (`RING_NUT_CLR_D`, 法兰螺母 Φ7.6 单边 +0.3), Z5 (`RING_CORNER_T`) 切到圆台顶 Z9.5 以上, 只削 r37.62–38.5 一条月牙。实测 (STEP 点分类): 角孔朝心偏 3.9 (r37.82) Z7/Z9 为空、偏 4.3 (r37.42) 为实体, Z4 (四角板) 实体; 内管 r30.5 Z0–16 全实体。让位圆到最近中央螺丝孔 (r35.2 Φ3.2, 22.5°/67.5°) 壁厚 10.6。check_v1_2 唯一非零仍为 board↔flange_disc 0.499 mm³; fasteners_v1_2 螺母↔线圈环 共用体积 0 (只剩电机螺丝↔电机 28.27/颗 = 预期啮合)。图纸说明加一行让位

## 2026-11-12 晚 XT60 压块改 M3 + 防呆 + 圆弧
- **新生成器** `scripts/xt60_clamp_v1_2.py` (由 `models/xt60_clamp_16p6x9p2x23p9/build_stl.py` 复制, 原 v4 件不动), 输出 `models/xt60_clamp_v1_2/` `xt60_clamp_v1_2.stl/.step` (压块, 局部 z0..11) + `xt60_shim_v1_2.stl/.step` (底垫, 局部 z0..4); STEP 由 m2b 从同一 mesh 转实体 (体积差 <0.01%)。`build_v1_2.py` 改读这两个 STEP (STL 读进来是壳, 紧固件干涉算不出体积)。v4.1~v4.10 的要求 (紧配零间隙、两件 0.1 装配间隙、止口、中央出线 U 口) 全保留, 旧 assert 在修剪/防呆/螺母座之前的中间体上照跑并全过, 修改后另有 V1.2 校核
- **M3** (用户「换成M3螺丝来装，依然从下往上打螺丝，螺母在上面」): 压块/底垫孔 Φ6.5 → **Φ3.4**, 孔位不变 (±12.5, Y0.55)。M3×20 超薄头从底盘底 Φ7×2 沉孔往上 (头支承 Z-4), 压块顶面 **Φ7.8 深 1.0 螺母座**, 法兰螺母坐 **Z12..15.7**, 螺丝尖 Z16 ⇒ 吃满 3.7, 穿出 0.3。底盘 C 孔 Φ6.4+Φ13×3 → **Φ3.2 + 底面 Φ7×2** (`M3_D/M3_CB_D/M3_CB_H`); 下罩压块顶上的螺母井 Φ14 Z13→19.5 → **Φ8.2 Z13→17.5** (`XT_NUT_WELL_D/H`, 尖到井顶 1.5)。网格跳孔判据仍按原 M6 沉孔留 XT60 位 (网格孔数不变, 30)
- **防呆** (用户「第二层的线是他的外壳 ... 加两个带弧形三角做一个防呆」): XT60 插合本体外壳一条短边 (9.2 那条) 两角是大圆角, 另一条两角小圆角。本体段槽 (Y-11.95..-0.05) 的 **+X 侧 (全局 +Y 侧) 上下两角**各加一条"带弧形三角" = R×R 方块减 R 圆, 凹弧贴接头圆角; 下角底面坐底垫凸台顶 (只接触)。`KEY_R = 1.5` / 小角 `KEY_R_SM = 0.5` **按图估, 待卡尺确认**; `KEY_SIDE = +1` (接线极性需要时改 −1)。正插零干涉; 反插 (转 180°) 两角共吃进 **7.9 mm³**, 对角方向深 **0.41**; 防呆条剪后长 9.2
- **圆弧** (用户「外面还不是圆弧 ... 玻璃托是圆形，要融为一体」): 压块 + 底垫外端用全局 **r110** (= 底盘/下罩外圆) 修剪。`XT_RF` 仍 112.5 (内移会撞安装法兰外裙 r85) ⇒ 接头口面伸出 r110 **2.5 (中线) / 2.8 (本体角)**。压块 Y 向长 26.9 → 中线 24.4 / X 端 22.75; 接头本体 11.9 里被压块包住 9.1–9.4。**开口端止口条 (底垫前边框 + 压块前台阶) 整条在 r110 外, 被剪掉**: 底垫 ±X/−Y 仍靠止口卡, +Y 改靠 M3 杆 (余量 0.2, 挪 0.3 被挡)
- 紧固件: XT60 M6×20 + M6 螺母 → **M3×20 + M3 法兰螺母** (BOM M3×20 8→10、法兰螺母 8→10, 采购各 20; M6×20 / M6 螺母两行删除)。fasteners_v1_2 共用体积只剩电机螺丝↔电机 28.27/颗 (预期啮合); check_v1_2 唯一非零仍为 board↔flange_disc 0.499 mm³
- 图纸: 底盘孔表 C 行改 M3 (同详图 D), 下罩两版说明改 Φ8.2 螺母井; 压块本身无 V1.2 图纸 (预览图 `out/xt60_clamp_v1_2_preview.png`, 不入库)

## 2026-11-12 夜 线圈驱动板: MOS 压块 + 电容卡件 (取代压盖), 三件共用板中心线
定子线圈驱动小板 XKT-801-49 (16.5×28) 固定。演变: 晚上先做大压盖 `coil_drv_cover_v1_2` (压 MOS + 压 PCB 两长边 + 底盘支撑筋) → 试过「筋单独打 + 底盘浅槽」→「mos锁住就可以」取消筋/压边 →「我们之前有一个类似xt60的件…就是锁这个mos的」大压盖换成 **MOS 压块** →「再做一个卡电容的吧，电容卡半圆」**电容卡件** → 照片「螺丝就在左右两边，上下放置是mos和电容」散热片竖放 →「mos这个卡件要做到以电路板中轴为对称」「散热片也是」。`coil_drv_cover_v1_2` 的 STEP/STL 与 `models/coil_drv_cover_v1_2/` 已删。
- **分工 / 文件**: `scripts/coil_drv_geom.py` 只管**布局 + 合并** (板 / MOS / 电容 / 散热片 / 底盘切口, 结果 `B.CD`), 参数快照写 `out/coil_drv_params.json`; **MOS 压块** = `scripts/mos_clamp_v1_2.py` `make_mos_clamp(MC_PARAMS)`, **电容卡件** = `scripts/cap_clamp_v1_2.py` `make_cap_clamp(CC_PARAMS)` (各自独立生成器, 自己出打印 STL/STEP 到 `models/mos_clamp_v1_2/`、`models/cap_clamp_v1_2/`)。coil_drv_geom 有生成器就调用并入 (r['clamp'] 进装配, r['disc_cuts'] 切底盘, r['screws'/'nuts'] 进预览; `CD.HAS_MC/HAS_CC`), 没有或报错就跳过 (`CD.MERGE_ERR`)。`scripts/coil_drv_v1_2.py` 校核 + 预览 `out/coil_drv_preview.png` + 局部装配 `models/mos_clamp_v1_2/coil_drv_asm_v1_2.step`; 板模型 `models/mos_clamp_v1_2/coil_drv_pcb_v1_2.step`
- **一字排布** (「mos偏心一点，电容是居中的…中间是电路板，电容和mos在一个平面就行，电容可以弯折脚」): 沿 Y 依次 MOS 背板尖 (+Y) → MOS → 引脚 4 → 板 28 → 电容引线 → 电解电容 Φ10×20 平躺。「从mos到电容长度是71mm」理解为 **MOS 背板尖 → 电容远端 = 71** (MOS 15.15 + 脚 4 + 板 28 + 引线 3.85 + 电容 20) — **待用户确认**
- **中轴线**: 散热片 / MOS 压块 / 电容卡件 / 电容轴 都按**板中心线 XPC = 57.05** 对称; MOS 中心线 XB = XPC + 2.95 = **60.0** (照片, 用户已确认)
- **整串比原位置 +X 2、+Y 2** (`XB` 58 → 60, `P0` −28 → −26): (a) 按板中线对称后, 压块 −X 端 (孔 XPC−15, 再 4.1 井 + 1 壁) 在 XPC 55.05 时到 x35.45, 碰线圈环方座 ±35.5; (b) 链长 71 时电容远端 y−51.85 碰下罩四角三角块 (|x|,|y| > 51, Z0..5, check 实测 cap↔seat 37.5 mm³)。现位置: MOS y6 (塑封根 `MOS_Y_LEAD`) → 21.15 (背板尖 `MOS_Y_TIP`), 板 x48.8..65.3 y−26..2, 电容 x52.05..62.05 **y−49.85..−29.85**
- **MOS 按规格书** (TO-220 中值): E 10.1 / D 15.15 (含背板) / A 4.45 / A1 背板 1.3 / A2 2.45 + c 0.5 ⇒ **引脚中心 Z2.7** (原假设 2.4) / H1 背板露出 6.5 / ΦP 3.6 Q 2.8 / b 0.8, b1 1.45×L1 3.05, e 2.54; 塑封段长取 D − H1 = 8.65。⇒ **PCB Z2.3..3.1** (只靠 MOS 引脚挂着, 不罩不压), 背面贴片电容底 Z−0.2 ⇒ 背面电容坑底 Z−0.7 (保留, 兼防 PCB 往下压到底盘)
- **散热片 40×20 竖放** (40 沿 Y): **x47.05..67.05 (按板中线居中) y−7..33** — MOS 背板 x55.0..65.05 完整落在散热片上 (+X 边留 2.0); 从 MOS 塑封根往 −Y 伸 13 (到板下 9), 再往 −Y 是背面电容坑 (电容底 Z−0.2 低于散热片顶 Z0), 槽↔坑壁 1.1; +Y 超出背板尖 11.85。底盘通槽零间隙。网格 M6 取消 **4 个** (x62.5, y±12.5 / +37.5 碰散热片槽, −37.5 碰电容弧形槽)
- **MOS 压块 `mos_clamp_v1_2`** (实心方块, 平顶, 底面盲槽 10.5 × 4.45 零过盈, 挡板顶背板尖, 两侧 2×M3 + 顶面 Φ8.2 螺母井, 按板中线对称, 槽偏 +2.95): 见 `mos_clamp_v1_2.py` 文件头 (另一 agent 写)
- **电容卡件 `cap_clamp_v1_2`** (实心方块, 底面半圆槽 R5.15, 顶面 Φ8.2 螺母井, 螺母倒放六角朝下坐井底; 牺牲层 0.2 只在打印 STL): 见 `cap_clamp_v1_2.py` 文件头。槽深取最小可行 **2.35** (cap_clamp 自算, 传 CAP_ZC=None): 电容轴 Z2.65, 顶 Z7.65, 卡件顶 Z9.0; 底盘弧形槽 R5.2 (电容底贴槽底, 底盘剩 3.65)
- **紧固件**: 两件各 2×M3 (长度以生成器 `screw_len` 为准, 目前 M3×12) 超薄头从底盘底 Φ7×2 沉孔往上, M3 法兰螺母**倒放**在件顶螺母井 (`fasteners_v1_2.flange_nut_inv`)。BOM: M3×12 = 线圈环 4 + MOS 压块 2 + 电容卡件 2 = 8, 法兰螺母 10 + 2 + 2 = 14, 采购量不变 (10 / 20)
- **底盘图纸**: 打印姿态改回 **顶面 (Z0) 贴床** (顶面平, 无支撑筋); 孔表 L = MOS 压块 2 + 电容卡件 2 (同详图 D); 说明写竖放散热片槽、电容弧形槽 (深 2.35)、取消 4 个网格孔
- **校核** (11-12 夜, 两件生成器都接入后全套重跑): `coil_drv_v1_2.py` 通过 — MOS↔压块 / 压块↔散热片 / 压块↔底盘 零间隙接触 0 体积, 电容↔卡件 0.15, 卡件↔定子盘/安装法兰 0.5, 卡件↔下罩 0.85, 电容↔下罩 1.15, 压块↔线圈环 1.75; 底盘新切口离现有孔 ≥1 (最近 卡件螺丝沉孔 1.66), 新切口之间 ≥1 (散热片槽↔压块沉孔 **1.00**, 槽↔背面电容坑 1.10)。`check_v1_2`: 唯一非零相交仍为 board↔flange_disc 0.499 mm³ (cd_* 全 0, 加了 cd_clamp / cd_capclamp × 定子盘/法兰/线圈环/控制板/下罩两版/XT60/底盘 及件间配对)。`fasteners_v1_2`: 共用体积只剩电机螺丝↔电机 28.27/颗 (预期); 压块 / 卡件 M3×12 尖 Z8, 螺母吃满 3.7, 尖离定子盘 1.5
- **XT60 螺母座取消** (同晚, 压块由 `xt60_clamp_v1_2.py` 另改): fasteners 里法兰螺母底 Z12 → **Z13** (13..16.7), M3×20 尖 Z16 ⇒ 啮合 **3.0**
- **3MF**: `export_3mf_v1_2.py` 全部装配、`out/pick_png.py` 选孔 3MF、`assembly_v1_2_整机+螺丝.3mf` 都含 MOS 压块 / 电容卡件 (有生成器才有) / 板 (元件级) / MOS / 电解电容 / 竖放散热片
- **待实测 / 待确认**: 71 的理解 (电容引线 3.85); `coil_drv_pcb_v1_2.COMP` 元件表与 `MOS_DX` 2.95 (按照片估 ±0.5); MOS 实物与规格书中值偏差 (槽 0 过盈, A 4.25–4.65)

## 2026-11-12 夜 定子盘底板 +1 / 铜螺母孔统一 4.2

用户「目标是所有都用4.2mm深度，然后我统一装4mm高度的」+ 线圈环剖面上方 6.5 段「加厚1mm，总高度不变」。
- **定子盘 flange_disc**: `FL_THIN` 3 → 2 ⇒ 底 `FL_Z0` 9.5 → **8.5** (Z8.5..13.5); 底板 1.5 → **2.5**, 线圈腔底 `CAV_Z0 = FL_Z0 + 2.5` = Z11.0 不变; 内外墙 5 高。`FL_TOP` 13.5 / `MF_TOP` 16 / `TUBE_TOP` 16 不变。
- **安装法兰外裙** r82.5–85 **不跟**: 单独按原 FL_THIN 3 切 (`MF_THIN_LOW`), 底仍 Z9.5 (下罩法兰螺母顶 Z8.7 下留 0.8)。
- **铜螺母孔全部 Φ4.2×4.2** (`INS_HOLE_D/H`), 统一装 M3×4 铜螺母 (底面齐平, 顶留 0.2): 底盘 G 8 + H 4 (原深 4.5, Z-6..-1.8); 定子盘外圈 r79 B 8 (原 Φ4.2×3, Z8.5..12.7, 外墙顶剩 0.8)。
- **线圈环**: 方座顶 = Φ77 圆台顶 Z8.5, 内管段 Z8.5..16 (7.5); 四角厚 `RING_CORNER_T` 5 → **4.5** (法兰螺母 Z4.5..8.2, 离定子盘底 0.3); M3×12 不变 (尾 Z8, 啮合 3.5, 离定子盘底 0.5)。出线口仍到 FL_Z0+2.7。
- **控制板让位** (定子盘底面, `BRD_POCKETS`, 自动按板上顶 > FL_Z0−0.5 的实体生成, 四周/顶各留 0.5): 2 颗电解电容 Φ6.3×7.7 (顶 Z9.31) → 圆坑到 Z9.81 (深 1.31, 两坑相连), 腔区剩底 **1.19**; 3P 排针 (顶 Z10.09) → 方坑到 Z10.59 (深 2.09), 腔区剩底 **0.41** (薄, 打印 2 层)。剩底 ≥1.5 与间隙 ≥0.5 不能同时满足; 若嫌薄可把排针剪短 ≥1.1 / 不焊排针, 再把 `BRD_POCKET_GAP` 或坑深改小。旧 0.499 mm³ 排针干涉消掉。
- 螺丝: 外圈上下盖 M3×5 → **M3×6** (尾 Z8.5 齐定子盘底, 啮合 4.0); 中央 M3×20 (啮合 3.5)、控制板 M3×6 (2.4)、线圈环角 M3×12 (3.5) 长度不变。BOM 铜螺母只剩 M3×4 一种 (24 颗)。
- 线圈驱动板两件 (`coil_drv_geom.py` 读 `B.FL_Z0`) 自动 Z_LIMIT 9.0 → 8.0、电容槽 3.0; 生成器/紧固件那 4 颗由另一 agent 处理。下罩加强筋 `GU_Z1 = FL_Z0 − 0.5` 自动跟。
- check_v1_2: `seat_nut` 改按法兰螺母实高 3.7 建模, 并加查 ↔ flange_disc; 全部相交体积 0 (控制板 ↔ 定子盘 0.50)。
- 图纸重出: 底盘 / 定子盘 (`.NEW.pdf`, 原 pdf 被占用) / 安装法兰 / 线圈环 (`.NEW2.pdf`, 原 pdf 与 .NEW.pdf 均被占用)。

## 2026-11-13 XT60 接头口面内接 r110 (不伸出)
- 用户: 只有 XT60 接头本身内接圆 (摸不到凸起), 压块/底垫外端仍 r110 圆弧 (中间一版误做成整件直线 + 底盘切平, 已撤回)。
- XT_RF 112.5 → **109.7** (口面宽 15.6: √(110²−7.8²)=109.72, 角 r109.98, 中线凹 0.3)。底盘 XT60 两孔 x100.0 → x97.2 (r100.8 → r98.0, 底盘需重打)。
- 压块内端 r82.8: 安装法兰外裙 r82.5–85 与法兰盘外缘 (+0.5 让位) 在压块处切到 Z13.5。
- 防呆三角 R1.5 → **R2.0** (用户: 三角小了; 图纸量大角 ~R1.9, 其余 ~R1.3)。xt60_clamp V1.2-f。

## 2026-11-13 晚 XT60 压块 V1.2-g: 底盘不重打, 压块孔外移 2.8
- 用户 11-12 已按 b0a79b0 打印底盘 (XT60 两孔 **(100.0, ±12.5) M6 Φ6.4 通 + 底面 Φ13×3 沉孔**) ⇒ 底盘保持打印件原样, 改压块 / 底垫。上面「底盘 XT60 孔 x97.2, 底盘需重打」作废。
- `build_v1_2.py`: XT_GHOLES_DISC 回到 x100.0 (`XT_HOLE_RC`), 孔型回到 b0a79b0 的 Φ6.4 + Φ13×3; XT_RF 仍 109.7 (接头口面内接 r110, 压块/底垫外端 r110 弧不变)。
- `xt60_clamp_v1_2.py` **V1.2-g**: 压块 + 底垫 2×M3 Φ3.4 孔局部 Y 0.55 → **−2.25** (= 径向外移 2.8, 孔心离开口面 12.5 → 9.7, 从护套段移进本体段), 法兰螺母跟着走。
  壁厚: 孔壁到本体段槽壁 3.00 / 护套段槽角 3.04 / 防呆三角在槽内 (≥3.0) / r110 外弧 7.52 (螺母法兰到外弧 5.42) / 开口端止口 5.90 / 侧止口 2.70 — 全部 ≥1.2。
- 五金: M3×20 (不变) + **M3 大垫片 Φ9×0.8 (DIN 9021)** 顶在 Φ13×3 沉孔顶 Z−3 (头支承 Z−3.8, 头底 Z−5.3 仍在盘底面内), 法兰螺母坐压块顶 Z13–16.7, 尖 Z16.2 ⇒ 啮合 3.2 (下罩井顶 Z17.5); M3 杆在 Φ6.4 孔里径向有 ±1.7 余量, 压块靠接头口面贴外圆/两杆定位, 装时摆正再拧。
- 底盘对比 (现版 vs b0a79b0 已打印件, 全盘布尔 XOR): **XT60 区 (x85–112, |y|<25) 差 0**。其它差别 (都在 b0a79b0 之后加的, 不必重打, 按需后加工):
  - 按键支架脚孔 (±27, 95): Φ3.2 通 + 底面 Φ7×2 沉孔 ×2 —— 钻孔 + 沉孔, 按键件最后验证时再钻。
  - 控制板 4 孔 (−32 / 39.01, 40.76 / 71.76): 打印件已有通孔 (底面 Φ4.2 到 Z−1.5 铜螺母孔), 改从下往上 M3×10 只需底面**加 Φ7×2 沉孔** (沉孔钻/扩孔)。
  - 线圈驱动板 MOS 压块 2 孔 (42.55 / 71.55, 14.32) + 电容卡件 2 孔 (46.55 / 67.55, −44.85): Φ3.2 通 + 底面 Φ7×2 —— 钻孔 + 沉孔。
  - 线圈驱动板散热片通槽 x47.05–67.05, y−7–33 (20×40 通) —— 要开方槽 (排孔 + 锉 / 电磨), 不是钻孔能做的; 电容弧形槽 (x52–62, y−50–−29, 顶面深 3) —— 电磨铣。
  - 打印件多出来的 (现版已填): 原 M6 网格孔 (62.5, −37.5 / −12.5 / 12.5 / 37.5) —— 多孔无害; 8 个中央铜螺母孔深 4.5 (现 4.2) —— 无害。
- 下罩压块顶 Φ8.2 螺母井跟孔走 (x97.2 → x100.0)。压块图纸 `models/xt60_clamp_v1_2/xt60_clamp_v1_2_drawing.pdf` / 底盘图纸孔表 C 已重出。

## 2026-11-13 线圈环电机出线口 270–310° 高 6
- 用户: 出线口对准实物出线 (~285–290°): 255–285° → **270–310° (宽 40), 高 Z0–6** (原到 Z11.2)。
- 中央 M3×20 #6 (292.5°, r35.2) 的螺杆正好穿过出线口 (Z0–6 段悬空), 电机线要绕开它; 用户知悉, "先这么改"。可选: 取消这颗 (剩 7 颗) 或出线口避开。
- 11-13 补: 310° 出线口边切过 315° 角耳, 底边剩一个尖三角 ⇒ 角耳出线口一侧 (310–315°, Φ77 外, Z≤4.5) 修成绕 M3 孔的 R4.3 圆 (法兰螺母 Φ7.6 + 0.5); 线圈环需重打。

## 2026-11-13 按键板 + 支架
- 按键板 40×20×1.6 (`scripts/key_board_outline_v1_2.py` → `models/key_board_v1_2/` DXF + 布局 PNG): +Y 侧竖放在下罩墙里, 正面朝外 y100.6 / 背面 y99.0, Z3–23, 板中心 x0; 板系 X → 整机 x = 20 − X。
  - 安装孔 2×Φ3.2 @ (3.5, 10) / (36.5, 10) = 整机 (±16.5, Z13); 背面孔周 Φ8 禁布 (法兰螺母), 正面立柱压板区 X 0..7 / 33..40, Y 0..14.5 禁布; 四边禁布 1 (插槽禁布取消)。
  - 元件: 按键 6×6×7 ×2 @ (11, 14.5) / (11, 5.5) (杆 Φ3.5 顶 y107.6); 三色 Φ5 @ (17, 10) **高 ≤7 (短体)**; 单色 Φ3 ×3 @ (22 / 26.5 / 31, 10) 高 ≤5.3。背面元件 ≤6 (y≥93)。
- 固定 (用户 11-13 更正, 板上不压铜螺母): U 形支架 `scripts/key_bracket_v1_2.py` → `models/key_bracket_v1_2/` (STL/STEP 打印姿态 + 装配位 STEP)。
  - 底条 x±21, y98–103.6, Z0–3 (板下沿坐上面); 两立柱 |x| 13–21 在板**前面** y100.6–103.6, Z0–17.5, Φ3.2 横孔; 立柱脚 |x| 13–20 前伸到 y106.2, Z0–5.2, 竖 Φ4.2×4.2 铜螺母孔 @ (±16.5, 103.3)。
  - 板: M3×8 超薄头 (头 y103.6–105.1) 从立柱前面往里穿立柱 + 板, 背面 M3 法兰螺母 (y99–95.3), 啮合 3.4。
  - 支架: 2×M3×8 从底盘底 Φ7×2 沉孔往上 → 支架脚 M3×4 铜螺母 (Z0..4), 进 4.0。底盘新孔 (±16.5, 103.3) Φ3.2 + 底面 Φ7×2; **网格孔一个没删** ((±12.5, 87.5) 距 16.3, 沉孔壁够)。
  - 打印: 装配姿态 (底面贴床) 免支撑, 只有铜螺母盲孔顶 Φ4.2 一小段桥接。
- 下罩 (合并版 / 分体版都带): 让位腔 = 支架 + 板 + 螺丝头 / 法兰螺母 + 前面元件 + 背面元件区 (y93–99, Z≤22) 各外包 +0.3, 底全开 (下罩从上罩下); 腔 x±21.3, y92.7–107.9, Z≤23.3, 离外圆 r110 最薄 **1.54** (按键杆槽角), 离墙内面 r90.8 ≥1.9。
  前皮通孔: 按键 Φ4 ×2, 三色 Φ5.3, 单色 Φ3.3 ×3, 与元件同轴。
- 注意: 按键杆 / LED 顶伸进前皮孔 (超出腔前面), 下罩竖着罩下来时外皮会刮到 —— 所以腔在每个元件正下方是一条通到底的竖槽 (杆宽 +0.3), 外面看不到, 只看到孔。三色 LED 若用标准 8.6 高 5mm, 顶 y109.2 会穿出外皮只剩 <1.5, 要换短体 (≤7) 或板上 LED 处挖。
- 紧固件: M3×8 +4 (支架 2 + 板 2), M3 法兰螺母 +2, 铜螺母 +2 (BOM 已加); check / fasteners / 3MF 已带按键板 (简模) + 支架。
- **11-13 L 形支架** (用户「支撑件做 L 型, 两边加三角加强; 底板依然螺丝从下往上, 螺母在上边; 板螺丝要沉孔, pcb 这边用螺母」; 取代上面 U 形 / 铜螺母方案):
  - 一件式 (两侧 L + 板下横条, 横条给板定位托底), bbox x±32, y90–104.1, Z0–18, 体积 ≈3.06 cm³; 11-13 用户「这个补齐, 从这个面朝下打印」⇒ 脚前端 (|x| 22.6–29) 补到立柱前面 y104.1, 前面成一整片平面, |x| 29–32 端部 45° 倒角 (外皮仍 ≥1.54); **打印: 前面朝下贴床, 免支撑** (沉孔 Φ7.4 在床面, 脚孔变横孔)。
  - 竖边 (立柱): |x| 13–22.6, y100.6–104.1 (厚 3.5, 原 3), Z0–18; 横孔 Φ3.2 @ (±16.5, Z13); 外侧 **Φ7.4×1.7 沉孔**埋超薄头 (头顶低于立柱面 0.2), 沉孔底剩壁 1.8。立柱内沿 |x|13 被板上按键 / LED 卡住不能内移, Φ7.4 沉孔在内侧破边 0.2 (头 Φ7 本身不出立柱)。
  - 横边 (脚): 板宽外 |x| 20.6–32, 往里伸 y90–100, 厚 4 (Z0–4); 竖孔 Φ3.2 @ **(±27, 95)**; 法兰螺母法兰外离脚边 ≥1.2。
  - 三角筋: |x| 20.6–22.6 (厚 2), 侧视梯形 立柱顶背面 (y100.6, Z18) → 脚内端 (y90, Z4); 离板边 0.6、离板背面法兰螺母 0.3、离脚螺母 0.6, 不碰背面元件区 (|x|<20, y93–99)。
  - 板: M3×8 超薄头从外往里, 支承 y102.4 (沉孔底), 背面法兰螺母 y99–95.3 吃满 3.7, 尖 y94.4。
  - 底盘: 2×M3×12 从底盘底 Φ7×2 沉孔往上 (孔 (±27, 95) Φ3.2), 穿底盘 + 脚, **法兰螺母坐脚顶 Z4–7.7**, 尖 Z8 (吃满, 露 0.3); 原 (±16.5, 103.3) 孔与脚铜螺母取消。网格孔不受影响 (assert 过)。
  - 下罩让位腔 (竖直柱体并集, 无倒扣): x±32.3, y89.7–107.9, Z≤23.3; 外皮最薄仍 **1.54** (按键杆槽角, 立柱处 3.1), 腔最内 r91.97 (墙内面 r90.8)。外皮按键 / LED 孔不变。
  - 紧固件变化: M3×8 −2 (6), M3×12 +2 (8), 法兰螺母 +2 (18), 铜螺母 −2 (20) (BOM md/csv 已改)。预览 `models/key_bracket_v1_2/key_bracket_v1_2_preview.png`。
- **11-13 前面平板 + 舌片按键 + 贴片件** (用户「支架前面做成一整块平板」+「沿红色切一下这个边, 这部分按压形变, 推到微动开关」+「两键拉开, 横缝放宽」; 取代上面立柱 / 外皮按键孔方案):
  - 元件全贴片 (`key_board_outline_v1_2.py` 常数 + DXF / 布局 PNG 已重出, 焊盘外包画上): 按键 6×6×7.5 ZX-QC66-7.5TP ×2 @ **(11, 18.5) / (11, 7.5)** = 整机 x9, Z21.5 / Z10.5 (**间距 11**; 本体高 3.45, 杆 Φ3.5 顶 y108.1, 行程 0.2, 焊盘外包 9.5×5.6 脚沿 X); 三色 1615 @ (17, 10); 单色 0603 ×3 @ (22 / 26.5 / 31, 10) (LED 不动)。
    **板高 20 → 22.5** (Z3–25.5, 上键本体 / 焊盘留四边禁布 1); 安装孔不变。正面孔周禁布 Φ4.8 (按键焊盘离孔心只 2.75); 按键焊盘外包离三色 LED 0.45。
  - 间距 11 的依据 (卡死的是舌片弹性力): 舌片根固定 Z2 / Z30 ⇒ 悬臂 a = Z下键 − 2 = 30 − Z上键; F ∝ 1/a³, F ≤ ~4 N ⇒ a ≥ 8.35 ⇒ 间距 ≤ 11.3; 取 11 (两片悬臂都 8.5)。板高跟着上键走。
  - 支架前面 = 一整块平板 |x|≤22.6, **y100.6–105.7 (厚 5.1)**, Z0–26.5, 压整板正面; 前面 y105.7 由 |x|22.6 角处外皮 ≥1.5 (实 1.55) + 腔间隙 0.3 定, 平板前面离外皮内面只 0.3。
    平板孔: 每颗 LED 单独 **Φ3.2 隔光通道** (只遮光不夹管); 杆孔 Φ4.0 ×2; 背面每键一个开关本体让位 (6.6 见方深 3.75) + 脚 / 焊盘让位 (10.1×6.2 深 1.5), 其余背面全贴板 (两键之间也压板)。
    薄处: 单色3 通道–板螺丝沉孔壁 0.2, 本体腔–沉孔 0.5, LED 通道之间 1.3; 脚让位与三色通道在板面处连通 0.65 宽 × 1.5 高 (焊盘离 LED 只 0.45, 放不下隔墙)。
  - 脚前端: 平板前面角 (|x|22.6) 起 45° 一路倒到脚端 (x±32, y96.3), 脚螺母法兰离倒角 0.65; 三角筋 / 脚 / 底盘 M3×12 + 法兰螺母不变。**打印: 前面 y105.7 朝下贴床, 免支撑**。体积 ≈6.82 cm³。
  - 板螺丝仍 **M3×8** 超薄头: 平板前面沉孔改 **Φ7.4×2.4** (支承 y103.3, 头顶低于平板前面 0.9), 穿平板剩壁 2.7 + 板 1.6, 尖 y95.3 齐法兰螺母端面 (吃满 3.7)。BOM 数量不变。
  - 按键 = 下罩外皮舌片: H 形缝 **缝宽 1.0** (0.8 用 0.4 嘴易糊死), 舌片宽 5.5, 竖缝 x 5.25–6.25 / 11.75–12.75, Z2–30; 上舌片根 Z30, 下舌片根 Z2; 舌片内面挖薄竖槽 (x5.25–12.75, 内面 y108.57, 底开到 Z−1, 罩下时杆从槽里滑过), 最薄 0.8 / 另一边 1.25; 内面凸点 Φ3 正对杆, 凸点面 y108.4 离杆顶 0.3 (凸点高 0.17)。
    `FLAP_MODE` 两种 (key_bracket_v1_2.py):
    - **'support' (主件现用, 用户 11-13 定)**: 横缝开到两凸点边各留 0.4 ⇒ **Z12.4–19.6 (高 7.2)**。**下罩正立打印, 切片支撑选 "处处" (everywhere) 或只在上舌片下面画支撑 (paint-on); 打完钳子从横缝把支撑拔出, 上舌片底面会毛**。
    - 'tie' (只做 A 试打块对照): 横缝 1.0 (Z15.5–16.5) + **下罩正立打印, 舌片两侧各一道 0.6 断开桥 (Z16.5–17.1), 打完用刀划开**; 上舌片底层成 ~7.5 跨两端搭桥, 免支撑。
    弹性力估算 (PLA E3000, δ = 0.3 间隙 + 0.2 行程, 不含开关 ~1.6 N; 两种模式一样, 力只看悬臂和截面): **上 3.80 N / 下 3.80 N (悬臂各 8.5)**。注意 F ∝ t³, 舌片打厚 0.1 力就 +30% 以上, 试打块实测为准。
  - 让位腔 x±32.3, y89.7–106.0, 平顶 Z≤26.8, **顶上 45° 双坡屋顶** (每个外包沿长边起脊, 高 = 短边/2, 最高 Z29.65 < 舌片根 Z30 / 墙实心 Z32; 只在外包投影内 ⇒ 外皮最薄不变、仍包住所有竖直下落外包); 改前平顶最长桥跨 8.2 (实际是短边方向搭桥, 不是 x±32 的 64)。
    外皮最薄 **1.55** (平板角, 舌片挖薄区除外), 腔最内 r91.97。外皮导光柱孔 **Φ3.0** ×4 (不再开按键孔)。
  - 导光柱改 Bivar PLP2 (或国产同款, 头 Φ3.3×0.8, 管身 Φ2.8, 压筋 Φ3.1; RGB 用雾化版 -D), `light_pipe_v1_2.py` 已改: 长度 = LED 顶到外皮外表面 − 0.3 ⇒ RGB 8.46 / 单色1 8.28 / 单色2 8.11 / 单色3 7.75 (按法兰实际支承点 8.49 / 8.30 / 8.19 / 7.90), 全部买 **PLP2-350 (8.9)** 剪短; 若厂家 8.9 含法兰 (管身 8.1) 则单色3 只剩 0.1 间隙, 要核图纸。
  - **舌片试打块** (`scripts/key_flap_test_v1_2.py` → `models/key_flap_test_v1_2/`, 不进装配 / check): 最终下罩 ∩ 盒 (x −17.5..17.75, y85–112 墙全厚, Z0–32), 保留原底面正立打印; 两件都按新间距 11:
    - `key_flap_test_v1_2_B_support.stl` (= 主件现状): 横缝 Z12.4–19.6, 无断开桥, 上舌片下加支撑 (everywhere 或 paint-on 只画上舌片底下), 钳子拔出, 底面会毛; 体积 ≈8.69 cm³, 估时 ≈42 min (0.4 嘴 0.2 层实心粗估, 支撑另计); 弹性力 上 / 下 3.8 / 3.8 N。
    - `key_flap_test_v1_2_A_tie.stl` (对照, 同新间距 11): 横缝 1.0 Z15.5–16.5 + 两侧断开桥 Z16.5–17.1, 免支撑, 打完刀划开; 体积 ≈8.73 cm³, 估时 ≈42 min; 弹性力 3.8 / 3.8 N。
  - 预览: `models/key_bracket_v1_2/key_bracket_v1_2_preview.png` (6 剖面) + `key_flap_front.png` (外皮舌片正视), `models/light_pipe_v1_2/light_pipe_preview.png`, 试打块各自 `_preview.png`。按键帽方案 (`key_cap_v1_2.py`) 作废。

- **11-13 晚 背面 J1 = JST GH 1.25 12P SM12B-GHS-TB (卧贴, 插头 GHR-12V-S) + 线到电机控制板 U24**:
  - 尺寸 (JST eGH.pdf + KiCad 库): 座 18.25 (含固定脚) × 深 4.05 × 高 4.25; 插头宽 16.25 / 长 5.7; 模型里插头外包按 宽 17.25 × 露出插口 5.0 × 厚 4.25 (保守)。
  - 位姿: 背面 (B.Cu), 封装原点板系 **(20, 8.45)** = 整机 x0, Z11.45; 翻面后 rotation 0, **插口朝板下沿 (整机 Z 向下)**, 插口面 Y6.0 (Z9), 本体 Z9–13.05, y94.75–99;
    pin1 板系 X26.875 (整机 x −6.875), pin12 X13.125 (x +6.875)。座边离板背法兰螺母 3.57。
  - 插头 Z4–9 (y94.75–99), 离支架底条顶 (Z3) 1.0; 插头下 Z0.2–4 给线弯 (≥3), 线弯外包离底条背面 (y98) 0.3; 线贴底盘 (Z0.2–1.8, 宽 14) 往 −Y 出下罩。
  - 下罩: 墙内面底部开**出线缺口 x ±9, Z0–3, y85–93** (接让位腔, 底开, 下罩竖直罩下时从线上滑过; 顶 18 宽平桥, 墙只 ~2 厚, 正立打印可桥)。支架**不用改** (底条只在板前面下方 + 板背后 1.0, 插头/线都在它后面)。
  - 板模型 (`key_board`) 加了 J1 本体 + 脚尾 + 插头外包 + 线弯/出线外包 + 背面 0603 R1–R6 / C1 (读 `pcb/key_board_v1_2/back_parts.json`, 高 0.6 / 0.9), check_v1_2 一起查。(11-13 (五) 起阻容在正面, 读 `front_parts.json`)
  - U24 (motor_ctrl STEP 'U24~CONN-SMD_SM12B-GHS-TB'): 板本地 x29.1–47.35, y10.7–15.57 ⇒ 整机中心 **(25.3, 73.1)**, 插口朝 +Y (板外长边, 离板边 0.7), 板顶 Z1.6–5.85。
    线路: U24 插头出 +Y (y≈80.5) → 斜着贴底盘到 (0, 91) 缺口 → 插头下 y≈96 弯上 ⇒ 路径 ≈40 mm。
  - 线型: 两头锁扣在不扭的扁平走线里同在一面 ⇒ **不扭 = 同向线 = J1 pin k ↔ U24 pin 13−k**; **pin1↔pin1 要用反向线** (两端锁扣在扁平线两面, 走线里拧半圈)。建议 反向 100 mm (拧半圈 + 余量盘在控制板外沿上方, 那里到定子盘底 Z8.5 有空) 或 同向 50 mm + 原理图 J1 线序倒排。
  - `pcb/key_board_v1_2/mech_constraints.json` (由 key_board_outline_v1_2.py 生成): J1 位姿 / 背面禁布 (螺母 Φ8, J1 courtyard, 插头+线区, 四边) / 背面贴片区 (限高 1.0) / 正面压板区与让位腔。预览 `models/key_bracket_v1_2/key_j1_preview.png`。
  - 按键焊盘常数更正 (封装 agent): 焊盘 1.5×1.1 中心 (±4.0, ±2.25) (原 BTN_PAD_C (6.5, 3.4) 是内边距), 外包 9.5×5.6 不变 ⇒ 支架让位不变。

- **11-13 (五) 单面贴 + 板 40×26 对称布局 (用户)**: JLC 只贴顶面更便宜 ⇒ R1–R6 / C1 由背面搬到正面; J1 留背面手焊 (平板盖住正面, J1 放不了正面)。
  - 板高 22.5 → **26** (下沿仍 Z3, 顶 Z29, 中线 Y13 = Z16)。按键 **转 90°** (焊盘外包 5.6 宽 × 9.5 高, Y2.75–12.25 / 13.75–23.25), 仍 (11, 18.5) / (11, 7.5) = Z21.5 / Z10.5 ⇒ 舌片 / 力不变 (上 / 下 **3.8 N**)。
    M3 孔移到中线 **(3.5, 13) / (36.5, 13)** (= 整机 x ±16.5, Z16)。LED 行在中线 Y13, 按键右边, 节距 4.5: **RGB X17 / 单色 21.5 / 26 / 30.5** (= 整机 x 3 / −1.5 / −6 / −10.5, Z16)。
  - 正面阻容一行 **Y19.5, 节距 2.0, 同向竖放 (脚 1 = LED 侧朝下)**: C1 17.75 (左端, 靠 J1 pin8 +3V3), R1–R6 19.75…29.75; 外包离 LED 隔光通道 3.68, 离按键让位 2.98, 离螺丝 (沉孔 Φ7.4) 4.50; 位号在 F.Fab 对齐一行, 正面无丝印。
  - PCB (`pcb/key_board_v1_2`, `bash scripts/build_all.sh`): DRC 0 / 未连 0 / ERC 0。规则改 **JLC 2 层基础工艺** (`.kicad_dru` + 板设置 + `.kicad_pro`): 线宽 / 间距 ≥0.15, 过孔 0.3/0.6, 环 ≥0.15, **孔间 ≥0.5**, 铜到边 ≥0.3, 1.6 FR4 1 oz, 仅通孔, 过孔离焊盘 ≥0.05 (无盘中孔)。
    J1 封装标 exclude-from-pos ⇒ **CPL 只有顶面 13 件 (无 J1)**; `fab/key_board_v1_2_BOM_JLC.csv` 去掉 J1, `fab/key_board_v1_2_BOM_全部_含手焊.csv` 带 "装配" 列 (J1 = 手焊)。原理图 / 背面丝印注明 J1 手焊。
    `front_parts.json` (新) = 正面阻容外包 + 高 (R 0.7 / C 1.0); `back_parts.json` 只剩 J1。
  - 支架: 平板背面开 **R/C 共用让位腔** 整机 x −10.53…3.03, Z20.98–24.03 (13.55×3.05), **深 1.3** (每件外包 +0.3, 件顶离腔底 R 0.6 / C1 0.3); 与 LED 隔光通道壁 **3.37**, 与按键腔 2.67, 与沉孔 4.08 (不连通, 不漏光); 平板剩 3.8。
    按键让位 (转 90°) 与三色通道壁 1.1 (原来在板面处连通); 单色3 通道–沉孔 0.7 (原 0.2)。平板顶 = 板顶 Z29 (原板顶 +1, 放不下); 下罩让位腔连屋顶限 **Z≤29.65** (分体版外卡环凸筋槽底 Z29.9, 玻璃承台 Z32 不动), 平板那段屋顶削平剩 5.0 平桥 (正立打印可桥)。仍前面朝下打印。
  - 外皮导光柱孔随 LED 移到 Z16。导光柱 (`light_pipe_v1_2.py`, 法兰实际支承): RGB **8.49** / 单色1 **8.30** / 单色2 **8.21** / 单色3 **7.94** ⇒ 剪到 8.4 / 8.3 / 8.2 / 7.9 (仍买 PLP2-350 8.9; 若 8.9 含法兰, 单色3 只剩 0.14 隙, 要核图纸)。
  - 预览: `pcb/key_board_v1_2/preview/key_board_v1_2_{copper,top,bottom}.png`, `models/key_board_v1_2/key_board_outline_v1_2_layout.png`, `models/key_bracket_v1_2/{key_bracket_v1_2_preview,key_flap_front,key_j1_preview}.png`, `models/light_pipe_v1_2/light_pipe_preview.png`。

## 待定 (2026-11-11, 法兰底减 3 / 上移 1 / 螺丝内移 r34 / 控制板内移 3.5 之后)
- 控制板 (法兰上移 1 后): 两颗 Φ6.3×7.7 电解电容顶压进定子盘底 0.06 (各 0.167 mm³); 3 根排针 (y≈74.7) 顶进定子盘外缘 0.79 (各 0.248 mm³) — 11-12 check_v1_2 实测, 唯一非零相交
- 法兰盘原 +X 方向线圈引线槽 (r40–61) 减薄后变通槽
- 玻璃罩版: 下罩初版待用户看; 装配顺序 下罩→电机→线圈环→法兰 (螺母井在法兰外裙下方); 转子承载盘上方的东西须在 r<92 内 (内卡)
- 立柱缩到 ≈349.8 或顶轴承架下移 10.2 (模型里还没改)
- 螺丝: 电机 M3×6~8 从盘底; 线圈环/法兰 8×M3×20 拧盘底铜螺母 (法兰上移 1 后沉孔底 z14.3 → 盘底 z-6 共 20.3, 螺尾离盘底 0.3)

## 2026-11-13 晚 新底盘 XT60 孔改标准 M3 (兼容 V1.2-g 压块)
- 用户「最近的底板也兼容这个 xt60」: 新底盘 XT60 两孔位置不变 (100, ±12.5), 孔型 M6 Φ6.4+Φ13×3 → **M3 Φ3.2 + 底面 Φ7×2 沉孔** (同其它 M3 盘底孔); M3×20 头支承 Z−4, 尖 Z16, 法兰螺母啮合 3.0, 不用垫片。
- 11-12 已打印旧底盘照用同一 V1.2-g 压块, 但要加 M3 大垫片 Φ9×0.8 (BOM 6b, 仅旧盘)。

## 2026-11-13 玻璃上 (顶盖): 玻璃上环 + 圆环玻璃 + 中心堵头
用户叫法: 原下罩 = **玻璃下** (`glass_shroud_v1_2`), 新顶环 = **玻璃上** (`glass_top_v1_2`)。顶盖共 3 件, 无螺丝。几何在 `build_v1_2.py` 4d 节 (`GT_*` / `GD_*` / `GH_*`)。
- 玻璃罩上端 **Z277.0** (= `Z_G` 32 + `GL_H` 245, `Z_GT`)。
- **玻璃上** (打印, Z265–281): 玻璃下的镜像。内卡 r90.8–94.8、外卡 r100.2–110, 玻璃槽单边 0.2; 端面以上板厚 4 (Z277–281); 外面 r110 与玻璃下 / 底盘齐平, 外卡外缘也留 1.5 直边。
  与玻璃下的差别: **内外卡同深 12** (玻璃下是 20 / 10), 底面同在 Z265, 正立打印时两卡一起落床; 外卡斜面在下面, 从 r101.2@Z265 (底平带 1) 到 r110@Z275.5, **与水平 50°**, 不用支撑。顶外缘倒角 1。
- **圆环玻璃** (外购, OD180 × ID20 × **10**, 11-13 用户 t5 → t10; 约 628 g): 坐在环内的窝里。窝 r90.3 (单边 0.3), 深 10.2, 窝口倒角 0.5; 托台 r85.5–90.3 在 Z270.8 (搭玻璃 4.5)。玻璃顶 Z280.8, **比环顶低 0.2**。托台底面 45° 斜回内卡内面 r90.8, 托台内缘直边 0.5。玻璃边 r90 到玻璃罩内壁 r95 有 5。
  - 定位: 径向靠窝。轴向靠自重 (约 628 g) 压在托台上。整个顶盖再靠自重 + 内外卡坐在玻璃罩上端, 不加零件。取下玻璃时可以提中心堵头。
- **中心堵头** `glass_top_hub_v1_2` (打印, 一件, Z267.6–283.8): 顶法兰 Φ32×3 (外缘倒角 1) 压在玻璃顶面上; 管 r8.2–9.8 穿玻璃 Φ20 孔 (单边 0.2); 孔下面是倒钩 r11 (钩 1.0), 钩面 30° 钩住玻璃底面, 下面 45° 导入到 r9。6 条 2 宽槽分出 6 爪, 爪长 12.2, 根部应变约 1.6% (建议 PETG, PLA 偏紧, 先试)。
  钩面是斜的: 玻璃实际比 10 厚 0.6 以内时爪带预压仍能扣上; 比 10 薄时, 差多少就留多少轴向间隙。
  - 可选 `GT_BEARING=1` (环境变量, 默认 0 = 实心堵头): 法兰加厚到 6.5, 内开 **688 轴承窝 Φ16.1×5** (顶留 1.5)。轴承从下面穿过爪内孔 Φ16.4 压进窝里; Φ8 轴也从下面进来。
- 打印姿态: 玻璃上**正立** (两卡底面 Z265 贴床; 玻璃槽顶 5.4 宽桥接); 堵头**法兰顶面朝下** (爪朝上; 倒钩钩面悬 1.2, 30°)。环 Φ220 超 A1 mini 180 床 (与玻璃下同, 要大床)。
- 与转子的间隙: 顶盖最低点 Z265 (两卡底 / 托台斜面根部), 堵头爪尖 Z267.6 (r≤11)。转子 / 显示屏须 **≤ Z262** (留 3)。模型里转子最高只到承载盘顶 Z32 (r89), 余 233。
  ⚠ 显示屏高度没有建进 V1.2 模型。若装 V1.0 的 ICN2260 灯板模组 (板高 225, 上沿 V1.0 Z326.23 → V1.2 **Z316.0**, 再加 V1.0 top_cap 7 = Z323), 会**超出玻璃罩上端 39**, 这根 245 高的玻璃罩装不下。按灯板下沿 Z91.0 不变算, 板高 ≤ 171 才能留 3。
  - 轴承: 玻璃版里没有东西伸到顶盖 (立柱版的 V0.4 frame_A/B 688 架在 Z360–376, 玻璃版不用)。要用顶轴承, 需要屏顶有一根 Φ8 轴, 伸到 Z≈281–286 (穿过堵头爪内孔进 688 窝), 屏顶仍要 ≤ Z262。
- 装配: 圆环玻璃放进玻璃上环的窝 → 堵头从上面压进 Φ20 孔 (6 爪咔哒扣住) → 整个顶盖套到玻璃罩上端。
- 3MF: `_玻璃罩版整机_合并` / `_分体外卡环` 都加了这 3 件; STL/STEP 在 `models/glass_top_v1_2/`、`models/glass_top_hub_v1_2/` (装配坐标); 图纸 `*_drawing.pdf` (`build_drawings_v1_2.py`); 预览 `models/glass_top_v1_2/glass_top_v1_2_{section,iso}.png` (`scripts/preview_glass_top_v1_2.py`)。check_v1_2 加了 玻璃上 ↔ 玻璃罩 / 圆环玻璃 / 堵头、堵头 ↔ 圆环玻璃。

## 2026-11-13 晚 玻璃下加高: 内卡顶 = V2 灯板 LED 下沿
用户: 「加高玻璃下这个件, 让玻璃的高度起点是屏幕 LED 下边沿」; 选「卡口顶 = LED 下沿」(内卡 20 不透光, 灯全露出来)。V2 转子堆叠: 转接板 (POV3D_V2_BaseBoard 140×80×1.6, 器件全在顶面) + MLK CZ06 核心板 (DF40 合高 3.0 + 板 1.6 + 顶面 ≈2.0 = 6.6), 转接板出 2 根 FPC 给桥板。
- 堆叠 (`build_v1_2.py` 4c 节 `BB_STANDOFF/BB_T/CZ06_H/CZ06_CLR`): 承载盘顶 Z32.0 → 转接板垫 3 (让插件脚) Z35.0–36.6 → CZ06 顶 Z43.2 → 留 2 → **灯板下沿 Z45.2** (承载盘到灯板 13.2)。
- V2 灯板 LED_V0.2.0 (11-13 版) 板高 208, 下沿 → 最下一行 LED 像素下沿 37.88 ⇒ **LED 下沿 Z83.08**, 灯板上沿 Z253.2。
- **玻璃下端 `Z_G` 32.0 → 63.08** (= LED 下沿 − 内卡 20); 下罩墙 r90.8–110 实心到 Z63.08, 内卡顶 Z83.08。合并版体积 826 cm³ / 分体下罩 786 cm³ (墙加高 31.08 约 +376 cm³, 很重, 以后可挖空)。
- 玻璃长度没改 (245) ⇒ 玻璃上端 Z308.08, 顶盖整体上移 31.08; 玻璃上最低处 Z296.08 离灯板上沿 **42.9**。按灯板上沿留 3 算玻璃最短 **205.1**。
- 灯板 STEP: `boards/led_v0.2.0_2026-11-13.step` (kicad-cli 导出, 板心原点, 未入库 11 MB)。转接板 + CZ06 + 灯板还**没建进装配/干涉**; 待查: 灯板 LED 面下部 J3 (VH 2P, 高 10.5, 离板下沿 1.4–9.3) 与转接板角上高件 (≤10.5) 是否相碰。
- check_v1_2 全部相交 0; 图纸重出: glass_shroud / glass_shroud_split / glass_clamp_ring / glass_top / glass_top_hub。

## 2026-11-13 晚 不装玻璃整机 + 装配图
用户「不装玻璃的组和图做一个」。`scripts/assembly_noglass_v1_2.py` (约 3.5 min):
- `assembly_v1_2_不装玻璃_整机+V2板.3mf` = 分体外卡环版整机去掉 玻璃罩 / 玻璃上 / 圆环玻璃 / 中心堵头, 加 V2 转子电路占位 (`scripts/v2_boards_v1_2.py`):
  转接板 140×80 (板框 + 每个器件 F.CrtYd 外框 × 限高方块, 读 `pov3d/pcb/projects/POV3D_V2_BaseBoard` 的 kicad_pcb; 长边 = 世界 X 平行屏面)、CZ06 60×35 (6.6 包络)、1 块 V2 灯板 (`boards/led_v0.2.0_2026-11-13.step`, 板背贴 Y=0, LED 面朝 +Y)。
- `assembly_v1_2_不装玻璃_装配图.{pdf,png}` (A3): 主视图 (从 +Y 看 LED 面) / 剖视 A-A (X=0) 带标高 / 俯视 / 图例。
- 实测 (脚本里 assert): 灯板 ↔ 转接板器件最近 5.30 (原担心的灯板 J3 vs 转接板 VH 座不碰)、灯板 ↔ CZ06 2.00、灯板最大转动半径 81.98 (玻璃下内面 r90.8, 余 8.82)。
- 未建: 第 2 块灯板 (背靠背间距/偏心未定)、桥板、FPC、转接板垫柱/安装孔对承载盘。
- `scripts/mf3_v1_2.py`: 从 export_3mf_v1_2.py 拆出的 mesh / write3mf (两个脚本共用; export_3mf 重跑过, 产物不变)。

## 2026-11-13 晚 (续) 玻璃下内卡顶 = LED 下沿 − 10
用户: 玻璃下的件决定能看到的下边界, 让这个边界比最下一行 LED 低 10。`VIEW_MARGIN = 10` ⇒ 内卡顶 (可视下边界) `Z_VIEW0` **73.08** (LED 下沿 83.08), **玻璃下端 `Z_G` 53.08** (上一版 63.08), 下罩矮 10: 合并版 705 cm³ / 分体下罩 665 cm³。
玻璃仍 245 ⇒ 上端 Z298.08, 玻璃上最低处离灯板上沿 32.9; 按留 3 算玻璃最短 215.1。check 全部相交 0; 玻璃下/外卡环/玻璃上/堵头图纸 + 不装玻璃整机/装配图已重出 (间隙不变: 5.30 / 2.00 / r81.98)。

## 2026-11-14 玻璃下拆上下两段 (8×M3 锁)
用户: 玻璃下太高, 做错要全部重来 ⇒ 拆开, M3 锁, 一边沉孔一边铜螺母; 有承重, 用 8 颗。
- **分界 Z32** (`SPLIT_Z` = 承载盘顶): 下段 `glass_shroud_lower_v1_2` (Z0→32, 368 cm³) = 原 32 高下罩, 三角块/筋/按键腔 (顶 Z23.3)/舌片 (根 Z30)/XT60 井都在里面; 上段 `glass_shroud_upper_v1_2` (Z32→53.08 墙 + 内卡到 Z73.08, 293 cm³) 是光环, **以后改可视高度只重打上段**。外卡环 `glass_clamp_ring_v1_2` 不变。
- 对中: 下段顶面止口凸筋 r104–106 高 2 (`RG_*`), 上段底槽单边 0.1。
- 8×M3×20 @ r98.5, 22.5°+45k (`JN_*`, 避开 +X XT60 / +Y 按键): 上段顶面 (玻璃座) Φ7 沉孔深 4.78 + Φ3.4 通; 下段顶面 Φ4.2×4.2 压 M3×4 铜螺母 (Z28..32)。支承 Z48.3, 尖 Z28.3, 啮合 3.7; 头顶 Z49.8 被玻璃端面 + 外卡环盖住。拆: 外卡环 → 玻璃 → 8 螺丝 → 上段, 不翻整机。
- 打印: 两段都底面贴床 (上段底面是止口槽面)。
- 旧 `glass_shroud_split_v1_2` 一体分体下罩作废 (变量 `shroud_split` 仍保留给合并校核); 合并版 `glass_shroud_v1_2` 没拆。
- 校核: check_v1_2 全部相交 0 (上↔下段 / 上段↔外卡环 / 玻璃 / 承载盘 1.78); fasteners: 新螺丝与件 0 共用, 只与 V1.0 立柱 (r95.2) 相交 —— 立柱本来就压在玻璃壁 r95–100 上, 玻璃版不装立柱, 预期。BOM: M3×20 10→18 (采购 30), 铜螺母 20→28 (采购 40)。

### 11-14 (二) 改穿通夹持
用户: 8 颗要真正夹住两段 (铜螺母只吃上段顶下 3.7, 不算夹持); 螺丝仍 Φ7 头沉孔; 螺母放下面, 用 M3 法兰螺母 (Φ7.6×3.7) 做沉孔, 下段底面要平。
- M3×45 超薄头 (`JN_L`), 上段顶面 Φ7 沉孔不变 (支承 Z48.3), **穿通上下两段**, 尾 Z3.3。
- 下段: 原顶面 Φ4.2 铜螺母孔取消 ⇒ Φ3.4 通 + **底面 Φ8.2 沉孔深 7.0** (`JN_NUT_D/JN_NUT_Z1`), 法兰螺母法兰朝上顶孔顶 (Z3.3..7.0, 吃满 3.7, 尖齐螺母端面); 底面仍平坐底盘。下段 364 cm³。
- 装: 先把 8 颗法兰螺母塞进下段底面孔 (下段装上底盘前), 上段压上后从顶面拧; 法兰螺母六角卡在 Φ8.2 圆孔里**不防转** —— 头一次拧时用 6 mm 套筒从底下顶住或孔里点胶; 想要免扶可改六角孔 (待用户定)。
- BOM: M3×20 18→10, 铜螺母 28→20, 法兰螺母 18→26, 新增 M3×45 ×8 (超薄头 45 长不好买可换普通 Φ7 平头, 头高 ≤3)。
- 校核: check_v1_2 上↔下段 / 外卡环 / 玻璃 0; fasteners 新螺丝/螺母与件 0, 仍只与 V1.0 立柱 (r95.2) 相交 (玻璃版没有立柱)。
- 11-14 (三) 用户: 上段顶面 Φ7 沉孔改**深 2** ⇒ 支承 Z51.08, 头顶 Z52.58 (玻璃底下 0.5); M3×45 不变 ⇒ 尾 Z6.08, 下段底面螺母孔加深到 **Φ8.2×9.78** (螺母 Z6.08..9.78)。校核同上 0。
- 11-14 (四) 用户: 改 M3×50, 下段底面螺母孔深 4 (Φ8.2×4) ⇒ 法兰螺母 Z0.3..4.0 (底面缩进 0.3), 尾 Z1.08, 啮合 2.92 (未穿透螺母 0.78)。校核 0。
- 11-14 (五) 用户: 按键板后面 (内侧) 不要留塑料 ⇒ 下罩墙在板背面 (y99) 到墙内面这段整块打通, x ±22.9 (筋外 +0.3), Z−1→32 (下段顶开口由上段盖住; 合并版 glass_shroud_v1_2 同样开到 Z32)。`KEY_OPEN_X/Y1` (build_v1_2.py)。支架/脚/螺丝不变。下段 359 cm³。校核 0。
- 11-14 (六) 用户: H 形按键横缝只要放得下支撑 ⇒ `FLAP_SUP_GAP` 2 (两键中线 Z15–17, 原 Z12.4–19.6 共 7.2)。按键让位腔顶上悬空 (45° 屋顶 + 平顶桥) 全去掉 ⇒ `POCKET_THRU_Z` 32.01: 让位腔外包 (含脚) 整块竖直打通到下段顶 Z32, 上段盖住; 止口凸筋在按键段 (x ±32.8) 断开。外皮 (r106–110, 最薄 1.55) 在这段只靠两侧连着, 背后 0.3 就是支架平板, 按压时贴到平板。下段 352 cm³。校核 0。
- 11-14 (七) 对 ZX-QC66-7.5TP 规格书 (Downloads/17F4CEFE….pdf): 本体 6×6×3.45 / H7.5 / 杆 Φ3.5 / 焊盘 1.5×1.1 中心 8.0×4.5 / 脚外宽 8.6 / 行程 0.2 全对; 漏了盖板四角凸点 (高出本体顶 ≈0.55) ⇒ `BTN_NUB_H` 0.55, 平板背面本体让位 3.75 → 4.3 深 (前面剩 0.8, 杆孔 Φ4 照旧)。KiCad 3D (lib/3d/SW_ZX-QC66-7.5TP.step) 包围盒高 7.5, 与机构一致。
- 11-14 (八) 用户: 转子承载盘直径改回 V0.4 rim_ring Φ170 (`RIM_D` 178→170)。V2 灯板转动半径 81.98 / 转接板角 r80.6 仍在 r85 内; 承载盘↔上段 5.78。

Parts:
C1: 100n; C_0603_1608Metric; MPN CC0603KRX7R9BB104; LCSC C14663
D1: XL-1615RGBC-RF; LED_XL-1615RGBC; MPN XL-1615RGBC-RF; LCSC C965840
D2, D3, D4: A-SP192YR6AC-A01-4T; LED_0603_A-SP192YR6AC; MPN A-SP192YR6AC-A01-4T; LCSC C5355430
J1: SM12B-GHS-TB(LF)(SN); JST_GH_SM12B-GHS-TB; MPN SM12B-GHS-TB(LF)(SN); LCSC C265421
R1, R4, R5, R6: 2.7k; R_0603_1608Metric; MPN 0603WAF2701T5E; LCSC C13167
R2, R3: 1k; R_0603_1608Metric; MPN 0603WAF1001T5E; LCSC C21190
SW1, SW2: ZX-QC66-7.5TP; SW_ZX-QC66-7.5TP; MPN ZX-QC66-7.5TP; LCSC C7470157

Connections:
+3V3: C1.1, D1.2 (A), D2.2 (A), D3.2 (A), D4.2 (A), J1.8
D1_BK: D1.4 (BK), R3.1
D1_GK: D1.3 (GK), R2.1
D1_RK: D1.1 (RK), R1.1
D2_K: D2.1 (K), R4.1
D3_K: D3.1 (K), R5.1
D4_K: D4.1 (K), R6.1
GND: C1.2, J1.5, J1.7, J1.12, J1.MP (MountPin), SW1.3 (B), SW1.4 (B), SW2.3 (B), SW2.4 (B)
KEY2: J1.9, SW1.1 (A), SW1.2 (A)
KEY3: J1.10, SW2.1 (A), SW2.2 (A)
KEY4: J1.11, R6.2
LED_IO1: J1.1, R1.2
LED_IO2: J1.2, R2.2
LED_IO3: J1.3, R5.2
LED_IO4: J1.4, R4.2
LED_MOSI: J1.6, R3.2

Notes on the sheet:
接口 J1 = GH1.25 12P (SM12B-GHS-TB), 对电机板 U24 同型座; 板上不加上拉 (电机板每个 KEY 已有 10k 上拉到 3V3 + 电容): 1 LED_IO1 → RGB-R (R1) 5 GND 9 KEY2 ← 上键 SW1 (按下接地, 低有效) 2 LED_IO2 → RGB-G (R2) 6 LED_MOSI → RGB-B (R3) 10 KEY3 ← 下键 SW2 3 LED_IO3 → 单色2 (R5) 7 GND 11 KEY4 → 单色3 (R6) (KEY 线改作输出; 电机板上的 10k 上拉无害, 其电容会让边沿变慢, 只做开关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
限流电阻 (3V3 供电, IO 拉低灌电流, V_OL ≈ 0.1 V; 用户 11-13: 原 270/100 Ω 太亮, 全部 ×10, 目标 ≈0.3–0.5 mA 指示亮度): I = (3.3 − Vf − 0.1) / R 红 (单色 D2–D4, RGB-R): Vf ≈ 1.7–1.8 V @ <1 mA R = 2.7 kΩ (C13167) → (3.3 − 1.75 − 0.1) / 2700 ≈ 0.54 mA 绿 / 蓝 (RGB-G/B): Vf ≈ 2.5–2.7 V @ <1 mA R = 1 kΩ (C21190) → (3.3 − 2.6 − 0.1) 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
单面贴 (用户 11-13): JLC 只贴顶面 (F) —— SW1 SW2 D1–D4 + R1–R6 C1 全在正面 (支架平板背面: 按键让位腔 / 每颗 LED Φ3.2 隔光孔 / R/C 共用让位腔)。 !! J1 (SM12B-GHS-TB) 在背面, 手焊: 平板盖住正面, J1 放不了正面。J1 不在 CPL 里 (封装标 exclude from pos), JLC BOM 也去掉 J1 (fab/*_手焊.csv)。 板系: 原点 = 板左下角 (从机器外面看正面), 整机 x = 20 − X, Z = 3 + Y。

Board: 2 copper layers, 40.0 x 26.0 mm, 16 parts (1 on the bottom side), 16 nets.

Other parts of the board:
H1, H2: MountingHole_3.2mm_M3

File v1.2/pcb/key_board_v1_2/fab/key_board_v1_2_BOM_JLC.csv:

Comment,Designator,Footprint,LCSC Part #,MPN,Qty
100n,C1,Capacitor_SMD:C_0603_1608Metric,C14663,CC0603KRX7R9BB104,1
XL-1615RGBC-RF,D1,key_board:LED_XL-1615RGBC,C965840,XL-1615RGBC-RF,1
A-SP192YR6AC-A01-4T,"D2,D3,D4",key_board:LED_0603_A-SP192YR6AC,C5355430,A-SP192YR6AC-A01-4T,3
2.7k,"R1,R4,R5,R6",Resistor_SMD:R_0603_1608Metric,C13167,0603WAF2701T5E,4
1k,"R2,R3",Resistor_SMD:R_0603_1608Metric,C21190,0603WAF1001T5E,2
ZX-QC66-7.5TP,"SW1,SW2",key_board:SW_ZX-QC66-7.5TP,C7470157,ZX-QC66-7.5TP,2
